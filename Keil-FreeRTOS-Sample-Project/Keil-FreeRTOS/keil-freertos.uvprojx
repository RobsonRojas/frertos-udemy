# Keil uVision project keil-freertos.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F446RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.10.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: keil-freertos
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: .\FreeRTOSv9.0.0\FreeRTOS\Source\include;.\FreeRTOSv9.0.0\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\Keil-FreeRTOS;.\trace_lib_src\GenericRecorderLibSrc\ConfigurationTemplate;.\trace_lib_src\GenericRecorderLibSrc\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group FreeRTOS
    ./FreeRTOSv9.0.0/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ./FreeRTOSv9.0.0/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ./: FreeRTOSConfig.h main.c stdout_USART.c
    ./FreeRTOSv9.0.0/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group trace_lib_src
    ./trace_lib_src/GenericRecorderLibSrc/: trcBase.c trcHardwarePort.c trcKernel.c trcKernelPortFreeRTOS.c trcUser.c
    ./trace_lib_src/GenericRecorderLibSrc/ConfigurationTemplate/: trcConfig.h
software components: CMSIS:CORE 4.3.0, Board Support:LED 1.1.0, Compiler:I/O:STDOUT 1.0.0, Device:Startup 2.5.0
